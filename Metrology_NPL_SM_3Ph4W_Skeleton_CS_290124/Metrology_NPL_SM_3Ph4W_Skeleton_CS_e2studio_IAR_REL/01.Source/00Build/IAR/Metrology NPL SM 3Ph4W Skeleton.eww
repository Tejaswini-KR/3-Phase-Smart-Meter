<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Metrology NPL SM 3Ph4W Skeleton.ewp</path>
    </project>
    <batchBuild />
</workspace>
