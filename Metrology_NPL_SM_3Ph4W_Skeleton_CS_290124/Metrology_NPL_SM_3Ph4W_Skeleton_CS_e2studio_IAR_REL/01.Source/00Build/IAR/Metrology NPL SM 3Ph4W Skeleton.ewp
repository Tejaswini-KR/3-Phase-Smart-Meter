# IAR project Metrology NPL SM 3Ph4W Skeleton.ewp, settings and files
configuration Release (RL78)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F10NPL RL78 - R5F10NPL
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 4128
  General.GenNearHeapSize: 16
  General.GenFarHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: __BOARD_REVISION=2; FEATURES_WQFR
  ICCRL78.CCDiagSuppress: Pa010,Pa089,Pe177,Pe186,Pa082
  ICCRL78.CCIncludePath2: ..\..\rl78i1c\application\calibration; ..\..\rl78i1c\application\dataflash; ..\..\rl78i1c\application\inst_read; ..\..\rl78i1c\application\startup; ..\..\rl78i1c\application\storage\metrology; ..\..\rl78i1c\appwrapper; ..\..\rl78i1c\driver; ..\..\rl78i1c\libwrapper\metrology; ..\..\shared\compiler\IAR; ..\..\shared\flash\fdl\IAR\incrl78; ..\..\shared\metrology\dc_detection\headers; ..\..\shared\metrology\filter\headers; ..\..\shared\metrology\metrologylibrary\headers
  OBJCOPY.OOCOutputFile: Metrology NPL SM 3Ph4W Skeleton.srec
  ILINK.IlinkOutputFile: Metrology NPL SM 3Ph4W Skeleton.out
  ILINK.IlinkIcfFile: lnkr5f10npl.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: lnkr5f10npl.icf
  group rl78i1c
    ../../rl78i1c/: main.c
  group rl78i1c/application/calibration
    ../../rl78i1c/application/calibration/: r_calib.c r_calib.h r_calib_sampling.c r_calib_sampling.h r_hoco_trimming.c r_hoco_trimming.h
  group rl78i1c/application/dataflash
    ../../rl78i1c/application/dataflash/: dataflash.c dataflash.h
  group rl78i1c/application/inst_read
    ../../rl78i1c/application/inst_read/: inst_read.c inst_read.h
  group rl78i1c/application/startup
    ../../rl78i1c/application/startup/: platform.c platform.h startup.c startup.h
  group rl78i1c/application/storage/metrology
    ../../rl78i1c/application/storage/metrology/: config_format.h config_storage.c config_storage.h
  group rl78i1c/appwrapper
    ../../rl78i1c/appwrapper/: wrp_app_mcu.c wrp_app_mcu.h
  group rl78i1c/driver
    ../../rl78i1c/driver/: r_cg_12adc.c r_cg_12adc.h r_cg_12adc_user.c r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_crc.c r_cg_crc.h r_cg_dsadc.c r_cg_dsadc.h r_cg_dsadc_user.c r_cg_dtc.c r_cg_dtc.h r_cg_dtc_user.c r_cg_elc.c r_cg_elc.h r_cg_elc_user.c r_cg_iica.c r_cg_iica.h r_cg_iica_user.c r_cg_mac32bit.c r_cg_mac32bit.h r_cg_mac32bit_user.c r_cg_macrodriver.h r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_rtc.c r_cg_rtc.h r_cg_rtc_user.c r_cg_sau.c r_cg_sau.h r_cg_sau_user.c r_cg_systeminit.c r_cg_tau.c r_cg_tau.h r_cg_tau_user.c r_cg_userdefine.h r_cg_wdt.c r_cg_wdt.h r_cg_wdt_user.c
  group rl78i1c/libwrapper/metrology
    ../../rl78i1c/libwrapper/metrology/: wrp_em_adc.c wrp_em_mcu.c wrp_em_pulse.c wrp_em_sw_config.h wrp_em_sw_property.c wrp_em_timer.c wrp_em_wdt.c
  group rl78i1c/libwrapper/metrology/filter
    ../../rl78i1c/libwrapper/metrology/filter/: r_dscl_iirbiquad_config.c rl78i1c_hpf_config.c
  group shared/compiler/IAR
    ../../shared/Compiler/IAR/: compiler.h typedef.h
  group shared/Flash/fdl/IAR/incrl78
    ../../shared/Flash/fdl/IAR/incrl78/: pfdl.h pfdl_types.h
  group shared/Flash/fdl/IAR/librl78
    ../../shared/Flash/fdl/IAR/librl78/: pfdl.a
  group shared/metrology/filter/headers
    ../../shared/metrology/filter/headers/: r_dscl_iirbiquad_i32_1.h r_dscl_iirbiquad_i32_2.h rl78_sw_hpf16.h
  group shared/metrology/filter/IAR
    ../../shared/metrology/filter/IAR/: hpf16_rl78_s3_ccrl_m.a r_dscl_iirbiquad_i32_1.a r_dscl_iirbiquad_i32_2.a
  group shared/metrology/metrologylibrary/headers
    ../../shared/metrology/metrologylibrary/headers/: em_calibration.h em_constraint.h em_core.h em_errcode.h em_measurement.h em_operation.h em_type.h wrp_em_adc.h wrp_em_mcu.h wrp_em_pulse.h wrp_em_sw_property.h wrp_em_timer.h wrp_em_wdt.h
  group shared/metrology/metrologylibrary/IAR
    ../../shared/metrology/metrologylibrary/IAR/: 230518_EMP4W_WQFR.a
